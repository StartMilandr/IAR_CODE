# IAR project HelloWorld_ES_DualCore.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MLDR124 Milandr MLDR124
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\SPL\CMSIS\CM4\CoreSupport; ..\..\SPL\CMSIS\CM4\DeviceSupport\MLDR124\inc; ..\..\SPL\CMSIS\CM4\DeviceSupport\MLDR124\startup\iar; ..\..\SPL\MLDR124_StdPeriph_Driver\inc; ..\..\SPL\MLDR124_StdPeriph_Driver\src; $PROJ_DIR$; ..; ..\..\SPL
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HelloWorld_ES_DualCore.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Milandr\MLDR124\MLDR124.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c mutex.s
    ../../SPL/MLDR124_StdPeriph_Driver/src/: mldr124_port.c
    ../../SPL/CMSIS/CM4/DeviceSupport/MLDR124/startup/iar/: startup_mldr124_DC.s system_mldr124.c
