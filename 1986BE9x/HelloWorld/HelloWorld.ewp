# IAR project HelloWorld.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x MDR1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\SPL\CMSIS\CM3\CoreSupport; ..\..\SPL\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc; ..\..\SPL\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\iar; ..\..\SPL\MDR32F9Qx_StdPeriph_Driver\inc; ..\..\SPL\MDR32F9Qx_StdPeriph_Driver\src; ..; ..\..\SPL
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HelloWorld.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Milandr\MDR1986VE9x\MDR32F1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Driver
    $MDR_CODE$/SPL/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c
  group src
    src/: main.c
  group Startup
    $MDR_CODE$/SPL/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/iar/: startup_MDR32F9Qx.s system_MDR32F9Qx.c system_MDR32F9Qx.h
