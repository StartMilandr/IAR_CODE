# IAR project HelloWorld_1T.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR1986VE1T Milandr MDR1986VE1T
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 36
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\SPL\CMSIS\CM1\CoreSupport; ..\..\SPL\CMSIS\CM1\DeviceSupport\MDR1986VE1T\inc; ..\..\SPL\CMSIS\CM1\DeviceSupport\MDR1986VE1T\startup\iar; ..\..\SPL\MDR32F9Qx_StdPeriph_Driver\inc; ..\..\SPL\MDR32F9Qx_StdPeriph_Driver\src; ..; ..\..\SPL
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HelloWorld_1T.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Milandr\MDR1986VE3\MDR1986VE3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Driver
    ../../SPL/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c
  group src
    ./: main.c
  group Startup
    ../../SPL/CMSIS/CM1/DeviceSupport/MDR1986VE1T/startup/iar/: startup_MDR1986VE1T.s system_MDR1986VE1T.c system_MDR1986VE1T.h
